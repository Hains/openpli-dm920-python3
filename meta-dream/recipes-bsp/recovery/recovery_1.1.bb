require recovery.inc

SRCREV = "22639116d31bdfada7907281cd64735bf4174599"

inherit opendreambox-git

BRANCH = "master"
