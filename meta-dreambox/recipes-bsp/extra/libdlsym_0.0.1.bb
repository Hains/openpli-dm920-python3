SUMMARY = "Helper library to link against preloadable libraries"
SECTION = "base"
LICENSE = "LicenseRef-LICENSE-CLOSED"
LIC_FILES_CHKSUM = "file://${OPENPLI_BASE}/meta-openpli/licenses/LICENSE-CLOSED;md5=2d5b03b35d4612637d67724b35738dd7"

SRCREV = "235cb0926c37b25f4509f9e5ab89431d4c46a6c3"

inherit autotools opendreambox-git lib_package pkgconfig
