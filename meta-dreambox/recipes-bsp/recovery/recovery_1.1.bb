require recovery.inc

SRCREV = "81ff8d40bbe21ec4bff1e397e4afdd2f1f3337e3"

inherit opendreambox-git

BRANCH = "master"
