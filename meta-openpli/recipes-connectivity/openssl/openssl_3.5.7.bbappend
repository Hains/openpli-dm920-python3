FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PV = "4.0.1"

SRC_URI[sha256sum] = "2db3f3a0d6ea4b59e1f094ace2c8cd536dffb87cdc39084c5afa1e6f7f37dd09"
