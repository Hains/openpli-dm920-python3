FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PV = "4.0.2"

SRC_URI[sha256sum] = "736b467530f916737b7031310ccb21d8218c6229e61e8e160cd1d3458cd543a8"
