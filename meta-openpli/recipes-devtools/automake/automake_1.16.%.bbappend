FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://revert-part-of-commit-6a675ef.patch"
