BBFILE_PRIORITY_mylayer = "1"

TARGET_CFLAGS="${target_libdir}/"
TARGET_CPPFLAGS="${target_libdir}/"
TARGET_CXXFLAGS="${target_libdir}/"
TARGET_LDFLAGS="${target_libdir}/"
