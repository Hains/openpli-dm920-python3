BBFILE_PRIORITY_mylayer = "1"

TARGET_CFLAGS="${target_libdir}/"
