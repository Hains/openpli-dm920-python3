INSANE_SKIP:${PN} += "file-rdeps"
