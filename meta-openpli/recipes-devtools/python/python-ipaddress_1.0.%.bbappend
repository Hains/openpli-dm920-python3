inherit allarch setuptools
