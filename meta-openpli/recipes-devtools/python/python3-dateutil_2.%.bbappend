PYPI_PACKAGE_SDIST = "python-dateutil"

include python3-package-split.inc
