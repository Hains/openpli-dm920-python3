RDEPENDS:${PN}:class-target:remove = "\
	cpp \
	cpp-symlinks \
"

include python-package-split.inc
