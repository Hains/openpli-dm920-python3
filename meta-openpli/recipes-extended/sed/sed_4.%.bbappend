ALTERNATIVE:${PN} = ""
