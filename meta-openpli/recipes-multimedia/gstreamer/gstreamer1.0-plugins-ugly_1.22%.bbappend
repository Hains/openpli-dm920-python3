PACKAGECONFIG = "${GSTREAMER_ORC} amrnb amrwb cdio"
