PACKAGECONFIG:append = " cdio"
