PACKAGECONFIG:append = " cdio"

PV = "1.28.1"

SRC_URI[sha256sum] = "4082f3cb063fccc3ffc04e5ab0854bafde82d1b373eb3c9eaa28115dd3f95a78"
