# use a patched version that supports ECMs

PV = "1.2.0"

SRC_URI = "git://github.com/oe-mirrors/libdvbcsa.git;protocol=https;branch=master \
           file://libdvbcsa.pc \
"
