SRC_URI +="file://add-dmx-source-enum-and-ioctl.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
