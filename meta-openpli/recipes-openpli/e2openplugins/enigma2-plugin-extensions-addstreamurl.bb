MODULE = "AddStreamUrl"
DESCRIPTION = "Add a stream url to your channellist"

inherit setuptools3-openplugins

require openplugins.inc
