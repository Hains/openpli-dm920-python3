MODULE = "AnalogClock"
DESCRIPTION = "permanent analog clock on the screen"

inherit setuptools3-openplugins

require openplugins.inc
