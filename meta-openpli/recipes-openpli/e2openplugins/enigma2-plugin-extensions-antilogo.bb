MODULE = "AntiLogo"
DESCRIPTION = "Prevent logo retention"

inherit setuptools3-openplugins

require openplugins.inc
