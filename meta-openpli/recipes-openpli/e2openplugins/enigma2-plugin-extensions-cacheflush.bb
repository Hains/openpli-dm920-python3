MODULE = "CacheFlush"
DESCRIPTION = "periodicaly flushing cache"

inherit setuptools3-openplugins

require openplugins.inc
