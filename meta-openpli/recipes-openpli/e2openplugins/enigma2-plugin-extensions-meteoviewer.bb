MODULE = "MeteoViewer"
DESCRIPTION = "meteo pictures viewer"

inherit setuptools3-openplugins

require openplugins.inc
