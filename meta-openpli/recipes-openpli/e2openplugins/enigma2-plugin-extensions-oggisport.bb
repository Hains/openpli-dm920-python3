MODULE = "OggiSport"
DESCRIPTION = "Italian daily Sport Tv guide"

inherit setuptools3-openplugins

PV_MOD = "1.0+git"
PKGV_MOD = "1.0+git${GITPKGV}"

require openplugins.inc
