MODULE = "PermanentVfdClock"
DESCRIPTION = "Show clock in VFD permanently"

inherit setuptools3-openplugins

require openplugins.inc
