MODULE = "RemoteControlChannel"
DESCRIPTION = "Remote control ir channel selection"

inherit setuptools3-openplugins

require openplugins.inc
