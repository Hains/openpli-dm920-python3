MODULE = "ScreenPosition"
DESCRIPTION = "Adjust the screen position"
PACKAGE_ARCH = "${MACHINE_ARCH}"

inherit setuptools3-openplugins

require openplugins.inc
