MODULE = "SetPicon"
DESCRIPTION = "Work with services picons"

inherit setuptools3-openplugins

require openplugins.inc
