MODULE = "TelekomSport"
DESCRIPTION = "Telekom Sport Plugin"

inherit setuptools3-openplugins

require openplugins.inc
