MODULE = "UsbFormatWizard"
DESCRIPTION = "Wizard to Format Usb devices "

inherit setuptools3-openplugins

PV_MOD = "1.0+git"
PKGV_MOD = "1.0+git${GITPKGV}"

require openplugins.inc
