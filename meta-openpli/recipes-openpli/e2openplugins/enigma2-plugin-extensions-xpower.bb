MODULE = "XPower"
DESCRIPTION = "remote PC power management for win and linux"

inherit setuptools3-openplugins

require openplugins.inc
