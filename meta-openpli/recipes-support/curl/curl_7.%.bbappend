EXTRA_OECONF:append = " \
    --without-ssl \
"
