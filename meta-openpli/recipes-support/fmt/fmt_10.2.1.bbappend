LIC_FILES_CHKSUM = "file://LICENSE;md5=b9257785fc4f3803a4b71b76c1412729"

SRC_URI = "git://github.com/fmtlib/fmt;branch=master;protocol=https"

SRCREV = "686339f7c12967975af0381eec7ca1a90af6bfcc"

PV = "pre11.0.0"
