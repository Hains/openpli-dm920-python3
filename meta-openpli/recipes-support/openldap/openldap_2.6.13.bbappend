PV = "2.6.15"

SRC_URI[sha256sum] = "bc91225dbfc50354033b1303bc91d1a7f6ddd1dc32fac950d79c28fe66d6bca8"
