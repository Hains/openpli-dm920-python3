SRCREV = "4b8ff51a29c4fdada2141847551702dc8ca6300b"

SRC_URI = "git://github.com/gabime/spdlog.git;protocol=https;branch=v1.x"    

PV = "1.11.pre1"
PKGV = "1.11.pre1"
