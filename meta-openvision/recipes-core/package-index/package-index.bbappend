do_package_index[depends] += "openvision-enigma2-image:do_image_complete"
