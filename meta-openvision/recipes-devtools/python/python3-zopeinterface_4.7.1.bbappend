FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
			file://feature-is-deprecated.patch \
"
